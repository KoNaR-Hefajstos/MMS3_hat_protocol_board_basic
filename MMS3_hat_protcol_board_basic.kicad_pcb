# Repository KoNaR-Hefajstos/MMS3_hat_protocol_board_basic

## KiCad design MMS3_hat_protcol_board_basic.kicad_pcb

Parts:
C3, C4: 10uF; C_0603; Voltage Rated 10V; Tolerance ±10%; Part CL10A106KP8NNNC; LCSC C19702
H1: M2.5 Mount; MountingHole_2.7mm_M2.5_DIN965_Pad_TopOnly
H2, H3, H4, H5, H6: M2.5 mount; MountingHole_2.7mm_M2.5
H7, H8, H9: Hole_Tooling_JLCPCB
J4, J11: Conn_01x04_Pin; JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal
J7: Conn_01x06_Pin; JST_XH_S6B-XH-A_1x06_P2.50mm_Horizontal
U3: AMS1117; SOT-223-3_L6.5-W3.4-P2.30-LS7.0-BR; Output Voltage 3.3V; Dropout Voltage 1.3V@(800mA); Part AMS1117-3.3; LCSC C6186

Connections:
+3V3: C4.1, J4.2, J7.2, J11.2, U3.2 (VOUT), U3.4 (VOUT); also elsewhere on the board
+5V: C3.1, U3.3 (VIN); also elsewhere on the board
/Chainbus.CS: J7.6; also elsewhere on the board
/Chainbus.MISO: J7.4; also elsewhere on the board
/Chainbus.MOSI: J7.5; also elsewhere on the board
/Chainbus.RX: J11.3; also elsewhere on the board
/Chainbus.SCK: J7.3; also elsewhere on the board
/Chainbus.SCL: J4.4; also elsewhere on the board
/Chainbus.SDA: J4.3; also elsewhere on the board
/Chainbus.TX: J11.4; also elsewhere on the board
GND: C3.2, C4.2, H1.1 (1_1), J4.1, J7.1, J11.1, U3.1 (GND); also elsewhere on the board

Notes on the sheet:
3V3 LDO
SPI
I2C
LM2596 Step-Down Regulator
UART

Parts:
C2: 100nF; C_0603; Voltage Rated 50V; Tolerance ±10%; Part CC0603KRX7R9BB104; LCSC C14663
U2: M24C64; SOIC-8_L5.0-W4.0-P1.27-LS6.0-BL; Supply Voltage 1.8V~5.5V; Part M24C64-RMN6TP; LCSC C79988

Connections:
+3V3: C2.1, U2.8 (VCC); also elsewhere on the board
/Chainbus.SCL: U2.6 (SCL); also elsewhere on the board
/Chainbus.SDA: U2.5 (SDA); also elsewhere on the board
GND: C2.2, U2.1 (A0), U2.2 (A1), U2.3 (A2), U2.4 (VSS); also elsewhere on the board

Notes on the sheet:
Identification EEPROM

Parts:
C1: 100nF; C_0603; Voltage Rated 50V; Tolerance ±10%; Part CC0603KRX7R9BB104; LCSC C14663
D3: Red; D_0603; Part KT-0603R; LCSC C2286
J3: Conn_01x04_Pin; PinHeader_1x04_P2.54mm_Vertical
R1: 330Ω; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF3300TCE; LCSC C25104
R2, R3, R4, R6, R7, R8, R9, R10, R11: 10kΩ; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF1002TCE; LCSC C25744
R5: 10kΩ; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF1002TCE; LCSC C25744; not fitted
U1: SN74CB3Q3384APW; TSSOP-24_4.4x7.8mm_P0.65mm; LCSC C469874

Connections:
+3V3: C1.1, D3.2, J3.4, R2.1, R3.1, R4.2, R6.1, R7.1, R8.1, R10.1, U1.24 (VCC); also elsewhere on the board
/Bus_switch/Chainbus_In.CS: U1.14 (2A1); also elsewhere on the board
/Bus_switch/Chainbus_In.MISO: U1.7 (1A3); also elsewhere on the board
/Bus_switch/Chainbus_In.MOSI: U1.8 (1A4); also elsewhere on the board
/Bus_switch/Chainbus_In.RX: U1.3 (1A1); also elsewhere on the board
/Bus_switch/Chainbus_In.SCK: U1.11 (1A5); also elsewhere on the board
/Bus_switch/Chainbus_In.SCL: U1.18 (2A3); also elsewhere on the board
/Bus_switch/Chainbus_In.SDA: U1.17 (2A2); also elsewhere on the board
/Bus_switch/Chainbus_In.TX: U1.4 (1A2); also elsewhere on the board
/Bus_switch/SEL1: R1.1, R4.1, U1.1 (~1OE), U1.13 (~2OE); also elsewhere on the board
/Chainbus.CS: R2.2, U1.15 (2B1); also elsewhere on the board
/Chainbus.MISO: R9.1, U1.6 (1B3); also elsewhere on the board
/Chainbus.MOSI: R11.1, U1.9 (1B4); also elsewhere on the board
/Chainbus.RX: R8.2, U1.2 (1B1); also elsewhere on the board
/Chainbus.SCK: R3.2, R5.1, U1.10 (1B5); also elsewhere on the board
/Chainbus.SCL: J3.2, R6.2, U1.19 (2B3); also elsewhere on the board
/Chainbus.SDA: J3.1, R10.2, U1.16 (2B2); also elsewhere on the board
/Chainbus.TX: R7.2, U1.5 (1B2); also elsewhere on the board
GND: C1.2, J3.3, R5.2, R9.2, R11.2, U1.12 (GND); also elsewhere on the board
unnamed: D3.1, R1.2

Notes on the sheet:
Bus Switch
Bus Pullups
'Selected' indicator
I2C Bus Connection

Parts:
J1: Chainbus in; PinHeader_2x16_P2.54mm_Vertical_SMD
J2: Chainbus Out; PinSocket_2x16_P2.54mm_Vertical_SMD

Connections:
+5V: J1.3, J1.5, J2.3, J2.5; also elsewhere on the board
+12V stby: J1.29, J2.29
/Bus_switch/Chainbus_In.CS: J1.22, J2.22; also elsewhere on the board
/Bus_switch/Chainbus_In.MISO: J1.28, J2.28; also elsewhere on the board
/Bus_switch/Chainbus_In.MOSI: J1.26, J2.26; also elsewhere on the board
/Bus_switch/Chainbus_In.RX: J1.32, J2.32; also elsewhere on the board
/Bus_switch/Chainbus_In.SCK: J1.24, J2.24; also elsewhere on the board
/Bus_switch/Chainbus_In.SCL: J1.20, J2.20; also elsewhere on the board
/Bus_switch/Chainbus_In.SDA: J1.18, J2.18; also elsewhere on the board
/Bus_switch/Chainbus_In.TX: J1.30, J2.30; also elsewhere on the board
/Bus_switch/SEL1: J1.2; also elsewhere on the board
/Interboard_connector/SEL2: J1.4, J2.2
/Interboard_connector/SEL3: J1.6, J2.4
/Interboard_connector/SEL4: J1.8, J2.6
/Interboard_connector/SEL5: J1.10, J2.8
/Interboard_connector/SEL6: J1.12, J2.10
/Interboard_connector/SEL7: J1.14, J2.12
/Interboard_connector/SEL8: J1.16, J2.14
BRD_VIN: J1.9, J1.11, J1.13, J1.15, J2.9, J2.11, J2.13, J2.15
GND: J1.1, J1.7, J1.17, J1.19, J1.21, J1.23, J1.31, J2.1, J2.7, J2.17, J2.19, J2.21, J2.23, J2.31; also elsewhere on the board

Notes on the sheet:
ChainBus In
ChainBus Out

Board: 2 copper layers, 100.0 x 50.0 mm, 34 parts (1 on the bottom side), 30 nets.

File jlcpcb/production_files/BOM-MMS3_hat_protcol_board_basic.csv:

Comment,Designator,Footprint,LCSC,Quantity
100nF,"C1,C2",C_0603,C14663,2
10kΩ,"R10,R11,R2,R3,R4,R6,R7,R8,R9",R_0402,C25744,9
10uF,"C3,C4",C_0603,C19702,2
330Ω,R1,R_0402,C25104,1
AMS1117,U3,SOT-223-3_L6.5-W3.4-P2.30-LS7.0-BR,C6186,1
M24C64,U2,SOIC-8_L5.0-W4.0-P1.27-LS6.0-BL,C79988,1
Red,D3,D_0603,C2286,1
SN74CB3Q3384APW,U1,TSSOP-24_4.4x7.8mm_P0.65mm,C469874,1
Chainbus Out,J2,PinSocket_2x16_P2.54mm_Vertical_SMD,,1
~,H8,Hole_Tooling_JLCPCB,,1
Conn_01x04_Pin,J3,PinHeader_1x04_P2.54mm_Vertical,,1
~,H7,Hole_Tooling_JLCPCB,,1
Conn_01x06_Pin,J7,JST_XH_S6B-XH-A_1x06_P2.50mm_Horizontal,,1
Conn_01x04_Pin,J4,JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal,,1
Conn_01x04_Pin,J11,JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal,,1
~,H9,Hole_Tooling_JLCPCB,,1
Chainbus in,J1,PinHeader_2x16_P2.54mm_Vertical_SMD,,1

## Commit log

2026-06-17 updated routing, removed megamind
