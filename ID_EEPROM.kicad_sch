File: ID_EEPROM.kicad_sch (KiCad schematic)
At the start: 2 parts, among them U2 M24C64

Commit message: updated routing, removed megamind
Other:
- company: (none) -> Moducard System
